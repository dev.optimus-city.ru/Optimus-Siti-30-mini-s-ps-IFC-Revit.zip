Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy: 30 мини.stp[712]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[713]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[714]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[715]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[716]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[717]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[718]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[719]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[720]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[721]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[722]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[723]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[724]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[725]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[726]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[727]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[728]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[729]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[730]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[731]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[732]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[733]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[734]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[735]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[736]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[737]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[738]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[739]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[740]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[741]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[742]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[743]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[744]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[745]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[746]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[747]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[748]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[749]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[750]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[751]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[752]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[753]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[754]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[755]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[756]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[757]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[758]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[759]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[760]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[761]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[762]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[763]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[764]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[765]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[766]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[767]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[768]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[769]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[770]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[771]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[772]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[773]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[774]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[775]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[776]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[777]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[778]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[779]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[780]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[781]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[782]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[783]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[784]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[785]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[786]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[787]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[788]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[789]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[790]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[791]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[792]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[793]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[794]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[795]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[796]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[797]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[798]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[799]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[800]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[801]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[802]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[803]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[804]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[805]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[806]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[807]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[808]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[809]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[810]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[811]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[812]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[813]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[814]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[815]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[816]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[817]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[818]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[819]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[820]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[821]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[822]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[823]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[824]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[825]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[826]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[827]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[828]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[829]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[830]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[831]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[832]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[833]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[834]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[835]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[836]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[837]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[838]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[839]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[840]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[841]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[842]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[843]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[844]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[845]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[846]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[847]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[848]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[849]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[850]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[851]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[852]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[853]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[854]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[855]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[856]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[857]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[858]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[859]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[860]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[861]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[862]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[863]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[864]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[865]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[866]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[867]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[868]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[869]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[870]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[871]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[872]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[873]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[874]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[875]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[876]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 30 мини.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
